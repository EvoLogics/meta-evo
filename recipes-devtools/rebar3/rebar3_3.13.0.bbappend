
SRC_URI = "git://github.com/erlang/rebar3;nobranch=1;protocol=https"

