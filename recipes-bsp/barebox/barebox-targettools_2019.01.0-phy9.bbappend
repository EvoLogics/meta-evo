COMPATIBLE_MACHINE += "|mx6ul-comm-module"

