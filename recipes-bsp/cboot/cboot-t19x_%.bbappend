FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-tegrabl_auth-fix-bug-decrypting-buffers.patch"

