FILESEXTRAPATHS:prepend:mx6ul-comm-module := "${THISDIR}/commod-mx6ul:"
FILESEXTRAPATHS:prepend:mx6-evobb := "${THISDIR}/mx6:"
