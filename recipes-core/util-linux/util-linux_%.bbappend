DISABLE_STATIC_sama5d2-roadrunner-evo = ""
FILES:${PN}-staticdev_sama5d2-roadrunner-evo = "${libdir}/*.a"
