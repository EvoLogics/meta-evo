SUMMARY = "A image for 32GiB SD card for EvoLogics roadrunner board"

require evologics-base-sd-image.inc

WKS_FILE = "${MACHINE}-32g.wks"
