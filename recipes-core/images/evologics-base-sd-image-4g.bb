SUMMARY = "A image for 4GiB SD card for EvoLogics roadrunner board"

require evologics-base-sd-image.inc

WKS_FILE = "${MACHINE}-4g.wks"
