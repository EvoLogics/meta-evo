DISABLE_STATIC:sama5d2-roadrunner-evo = ""
FILES:${PN}-staticdev:sama5d2-roadrunner-evo = "${libdir}/*.a"
