require swupdate-images-evo-comm.inc

SWUPDATE_SIGNING = "RSA"
SWUPDATE_PRIVATE_KEY = "/work/private/evo-updater.pem"
SWUPDATE_PASSWORD_FILE = "/work/private/evo-updater.pass"
