require swupdate-images-evo-comm.inc

SWUPDATE_SIGNING = "CMS"
SWUPDATE_CMS_KEY = "/work/private/cms_fwp.pem"
SWUPDATE_CMS_CERT = "/work/private/cms_fwc.crt"
SWUPDATE_CMS_EXTRA_CERTS = "/work/private/cms_mid.crt"
SWUPDATE_PASSWORD_FILE = "/work/private/cms_pss.txt"
