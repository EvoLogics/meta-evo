SUMMARY = "Random number generator daemon"

FILESEXTRAPATHS:prepend:mx6ul-comm-module := "${THISDIR}/commod-mx6ul:"
